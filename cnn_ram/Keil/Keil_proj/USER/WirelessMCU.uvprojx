# Keil uVision project WirelessMCU.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: WirelessMCU.axf
  AfterMake: fromelf -cvf .\WirelessMCU.axf --vhx --32x1 -o WirelessMCU.hex
  AfterMake: fromelf -cvf .\WirelessMCU.axf -o WirelessMCU.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CORE;..\CortexM0_FWLib;..\OBJ;..\SYSTEM;..\USER;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group SYSTEM
    ../SYSTEM/: system_CMSDK_CM0.c system.c
  group HARDWARE
    ../HARDWARE/: SYG_M0_gpio.c SYG_M0_uart.c SYG_M0_printk.c SYG_M0_dma.c
  group USER
    ./: main.c SYG_M0_it.c
  group CORE
    ../CORE/: startup_CMSDK_CM0.s
